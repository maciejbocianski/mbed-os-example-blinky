<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\my_blinky.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>